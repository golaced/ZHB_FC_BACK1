# Keil uVision project UCOSII-3.uvprojx, settings and files
target UCOSII-3 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: UCOSII-3 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\BEEP;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\TPAD;..\MALLOC;..\HARDWARE\flash;..\HARDWARE\KF;..\HARDWARE\GPS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../HARDWARE/IIC/: parameter.c datasheet.txt ucos_task.c include.h
    ./: main.c
    ../UCOSII/CONFIG/: os_cfg.h
  group SYSTEM
    ./: stm32f4xx_it.c system_stm32f4xx.c
    ../CORE/: startup_stm32f40_41xxx.s
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_adc.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group HARDWARE
    ../HARDWARE/IIC/: iic_fc.c flash.c iic_soft.c led_fc.c pwm_out.c spi_nrf.c time.c ultrasonic.c dma.c iic_sonar.c
    ../HARDWARE/flash/: flash_w25.c
    ../HARDWARE/GPS/: gps.c
  group COMMUNICATION
    ../HARDWARE/IIC/: nrf.c rc_mine.c rc.c usart_fc.c
  group MEMS
    ../HARDWARE/IIC/: hml_sample.c mpu6050.c ms5611_2.c bmp_adc.c flow.c
  group CONTROL
    ../HARDWARE/IIC/: eso.c height_ctrl.c att_control.c neuron_pid.c sonar_avoid.c visual_contol.c
  group MATH&FUSION
    ../HARDWARE/IIC/: fliter.c my_math.c alt_kf.c error.c
  group EKF
    ../HARDWARE/IIC/: imu.c Quaternion.c sckf.c FastMath.c Matrix.c UKF.c EKF.c mini_ARSH.c miniMatrix.c ckf.c ekf_math.c ekf_ins.c imu_m.c
    ../DSP_LIB/: arm_cortexM4lf_math.lib
    ../HARDWARE/KF/: baro_ekf.c
